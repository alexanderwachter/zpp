## Kconfig
```kconfig
# CAN options
#
menuconfig ZPP
	bool "Zephyr++"
	help
	  Enable C++ Shim for some Zephyr APIs
```
